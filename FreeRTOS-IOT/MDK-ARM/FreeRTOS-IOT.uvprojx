# Keil uVision project FreeRTOS-IOT.uvprojx, settings and files
target FreeRTOS-IOT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: FreeRTOS-IOT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/STM32F1xx_HAL_Driver/Inc;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/include;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/CMSIS/Device/ST/STM32F1xx/Include;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/CMSIS/Include;..\Peripheral\lcd;..\Peripheral\LED;..\Peripheral\spi2;..\Peripheral\timer3;..\Peripheral\uart1;..\Peripheral\uart2;..\Peripheral\uart3;..\Peripheral\wifi;..\Peripheral\dht12;..\APP\lcd_ui;..\APP\net_time;..\APP\onenet_http;..\APP\onenet_mqtt;..\APP\mqtt_client;..\APP\seniverse_http;..\APP\modbus_rtu;..\system\delay;..\system\structure;..\system\config;..\system\sys;..\system\usart
  asm include: ../Core/Inc;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/STM32F1xx_HAL_Driver/Inc;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/include;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/CMSIS/Device/ST/STM32F1xx/Include;D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c fsmc.c i2c.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
    ../APP/lcd_ui/: lcd_ui.c
    ../APP/onenet_http/: onenet_http.c
    ../APP/seniverse_http/: seniverse_http.c
    ../APP/net_time/: net_time.c
    ../APP/modbus_rtu/: modbus_rtu.c
    ../APP/mqtt_client/: mqtt_client.c
    ../APP/onenet_mqtt/: onenet_mqtt.c
  group Drivers/STM32F1xx_HAL_Driver
    D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_nor.c stm32f1xx_hal_sram.c stm32f1xx_hal_nand.c stm32f1xx_hal_pccard.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    D:/LenovoSoftstore/Install/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Peripheral
    ../Peripheral/lcd/: bsp_ili9341_lcd.c fonts.c
    ../Peripheral/LED/: led.c
    ../Peripheral/spi2/: spi2.c
    ../Peripheral/timer3/: timer3.c
    ../Peripheral/uart1/: uart1.c
    ../Peripheral/uart2/: uart2.c
    ../Peripheral/uart3/: uart3.c
    ../Peripheral/wifi/: wifi.c
    ../Peripheral/dht12/: dht12.c
  group System
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/structure/: structure.c
    ../system/usart/: usart.c
software components: CMSIS:CORE 4.3.0
